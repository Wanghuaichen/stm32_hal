# Keil uVision project F103ZET6.uvprojx, settings and files
target F103ZET6 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103ZET6
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99 --locale=english
  c include: ../Inc;           ..\STemWinLibrary532\Config;           ..\STemWinLibrary532\inc;           ..\STemWinLibrary532\Demo;           ..\STemWinLibrary532\inc;           ..\emwin;           ..\SeggerEval\GUI\Include;           ..\Modbus\ascii;           ..\Modbus\include;           ..\Modbus\port;           ..\Modbus\rtu;           ..\Modbus\tcp;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Drivers/STM32F1xx_HAL_Driver/Inc;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Drivers/CMSIS/Device/ST/STM32F1xx/Include;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Drivers/CMSIS/Include
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c gpio.c crc.c usart.c freertos.c stm32f1xx_hal_timebase_TIM.c iwdg.c
  group Own
    ../Own/: 12864TXA.c Rtos.c Key.c
  group STemwin
    ../STemWinLibrary532/Config/: GUIConf.c GUIDRV_Template.c LCDConf_Lin_Template.c
    ../STemWinLibrary532/OS/: GUI_X_OS.c
    ../STemWinLibrary532/Lib/: STemWin532_CM3_OS_Keil.lib
  group emwin
    ../emwin/: GUIDEMO_Start.c
  group Drivers/STM32F1xx_HAL_Driver
    C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_crc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_gpio.c stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c
  group Middlewares/FreeRTOS
    C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/: event_groups.c timers.c queue.c croutine.c list.c tasks.c
    C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/xp/STM32Cube/Repository/STM32Cube_FW_F1_V1.6.0/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0
